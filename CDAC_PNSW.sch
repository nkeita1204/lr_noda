v {xschem version=3.4.8RC file_version=1.2}
G {}
K {}
V {}
S {}
E {}
N 370 -150 370 -60 {lab=OUT}
N -30 -150 -30 -60 {lab=OUT}
N -500 -150 -500 -60 {lab=OUT}
N -950 -150 -950 -60 {lab=OUT}
N -1480 -150 -1480 -60 {lab=OUT}
N -30 -150 50 -150 {lab=OUT}
N 50 -150 120 -150 {lab=OUT}
N 540 -150 650 -150 {lab=OUT}
N 370 -0 370 90 {lab=Vrefl}
N 200 -150 370 -150 {lab=OUT}
N -450 -150 -210 -150 {lab=OUT}
N -970 -150 -660 -150 {lab=OUT}
N -1340 -150 -1040 -150 {lab=OUT}
N -100 250 -100 310 {lab=Vrefh}
N -570 250 -570 310 {lab=Vrefh}
N -1020 250 -1020 310 {lab=Vrefh}
N 370 250 370 290 {lab=Vrefl}
N 50 250 50 290 {lab=Vrefl}
N -420 250 -420 290 {lab=Vrefl}
N -870 250 -870 290 {lab=Vrefl}
N 370 -150 540 -150 {lab=OUT}
N 610 150 610 290 {lab=Vrefl}
N 370 290 610 290 {lab=Vrefl}
N 610 100 640 100 {lab=VSS}
N 530 100 560 100 {lab=resetPD}
N -1400 -150 -1340 -150 {lab=OUT}
N -1040 -150 -970 -150 {lab=OUT}
N -1230 290 -870 290 {lab=Vrefl}
N -870 290 -740 290 {lab=Vrefl}
N -740 290 -420 290 {lab=Vrefl}
N -420 290 -270 290 {lab=Vrefl}
N -270 290 50 290 {lab=Vrefl}
N 50 290 190 290 {lab=Vrefl}
N 190 290 370 290 {lab=Vrefl}
N -660 -150 -450 -150 {lab=OUT}
N -210 -150 -30 -150 {lab=OUT}
N 120 -150 200 -150 {lab=OUT}
N -5290 -1690 -5210 -1690 {lab=D11}
N -5100 -1690 -5000 -1690 {lab=D11b}
N -5170 -1780 -5170 -1730 {lab=VDD}
N -4890 -1690 -4810 -1690 {lab=D10}
N -4700 -1690 -4600 -1690 {lab=D10b}
N -4770 -1780 -4770 -1730 {lab=VDD}
N 370 90 370 250 {lab=Vrefl}
N -1910 -150 -1910 -60 {lab=OUT}
N -2380 -150 -2380 -60 {lab=OUT}
N -2830 -150 -2830 -60 {lab=OUT}
N -3360 -150 -3360 -60 {lab=OUT}
N -1910 -150 -1830 -150 {lab=OUT}
N -1830 -150 -1760 -150 {lab=OUT}
N -2330 -150 -2090 -150 {lab=OUT}
N -2850 -150 -2540 -150 {lab=OUT}
N -3220 -150 -2920 -150 {lab=OUT}
N -1980 250 -1980 310 {lab=Vrefh}
N -2450 250 -2450 310 {lab=Vrefh}
N -2900 250 -2900 310 {lab=Vrefh}
N -1830 250 -1830 290 {lab=Vrefl}
N -2300 250 -2300 290 {lab=Vrefl}
N -2750 250 -2750 290 {lab=Vrefl}
N -3280 290 -3110 290 {lab=Vrefl}
N -2920 -150 -2850 -150 {lab=OUT}
N -3110 290 -2750 290 {lab=Vrefl}
N -2750 290 -2620 290 {lab=Vrefl}
N -2620 290 -2300 290 {lab=Vrefl}
N -2300 290 -2150 290 {lab=Vrefl}
N -2150 290 -1830 290 {lab=Vrefl}
N -1830 290 -1690 290 {lab=Vrefl}
N -2540 -150 -2330 -150 {lab=OUT}
N -2090 -150 -1910 -150 {lab=OUT}
N -1760 -150 -1680 -150 {lab=OUT}
N -1680 -150 -1400 -150 {lab=OUT}
N -1690 290 -1370 290 {lab=Vrefl}
N -1370 290 -1230 290 {lab=Vrefl}
N -3880 -150 -3880 -60 {lab=OUT}
N -4410 -150 -4410 -60 {lab=OUT}
N -4270 -150 -3970 -150 {lab=OUT}
N -3950 250 -3950 310 {lab=Vrefh}
N -3800 250 -3800 290 {lab=Vrefl}
N -4330 -150 -4270 -150 {lab=OUT}
N -3970 -150 -3900 -150 {lab=OUT}
N -4160 290 -3800 290 {lab=Vrefl}
N -4840 -150 -4840 -60 {lab=OUT}
N -5310 -150 -5310 -60 {lab=OUT}
N -4840 -150 -4760 -150 {lab=OUT}
N -4760 -150 -4690 -150 {lab=OUT}
N -4910 250 -4910 310 {lab=Vrefh}
N -5380 250 -5380 310 {lab=Vrefh}
N -4760 250 -4760 290 {lab=Vrefl}
N -5230 250 -5230 290 {lab=Vrefl}
N -6210 290 -6040 290 {lab=Vrefl}
N -6040 290 -5680 290 {lab=Vrefl}
N -5680 290 -5550 290 {lab=Vrefl}
N -5550 290 -5230 290 {lab=Vrefl}
N -5230 290 -5080 290 {lab=Vrefl}
N -5080 290 -4760 290 {lab=Vrefl}
N -4760 290 -4620 290 {lab=Vrefl}
N -5020 -150 -4840 -150 {lab=OUT}
N -4690 -150 -4610 -150 {lab=OUT}
N -4610 -150 -4330 -150 {lab=OUT}
N -4620 290 -4300 290 {lab=Vrefl}
N -4300 290 -4160 290 {lab=Vrefl}
N -3280 -150 -3220 -150 {lab=OUT}
N -3800 -150 -3280 -150 {lab=OUT}
N -3900 -150 -3800 -150 {lab=OUT}
N -3800 290 -3280 290 {lab=Vrefl}
N -3280 250 -3280 290 {lab=Vrefl}
N -6210 290 -6210 360 {lab=Vrefl}
N -5840 320 -100 320 {lab=Vrefh}
N -100 310 -100 320 {lab=Vrefh}
N -570 310 -570 320 {lab=Vrefh}
N -1020 310 -1020 320 {lab=Vrefh}
N -1400 250 -1400 290 {lab=Vrefl}
N -1550 250 -1550 320 {lab=Vrefh}
N -1980 310 -1980 320 {lab=Vrefh}
N -2450 310 -2450 320 {lab=Vrefh}
N -2900 310 -2900 320 {lab=Vrefh}
N -3430 250 -3430 320 {lab=Vrefh}
N -3950 310 -3950 320 {lab=Vrefh}
N -4330 250 -4330 290 {lab=Vrefl}
N -4480 250 -4480 320 {lab=Vrefh}
N -4910 310 -4910 320 {lab=Vrefh}
N -5380 310 -5380 320 {lab=Vrefh}
N -6360 320 -5840 320 {lab=Vrefh}
N -4510 -1690 -4430 -1690 {lab=D9}
N -4320 -1690 -4220 -1690 {lab=D9b}
N -4390 -1780 -4390 -1730 {lab=VDD}
N -4110 -1690 -4030 -1690 {lab=D8}
N -3920 -1690 -3820 -1690 {lab=D8b}
N -3990 -1780 -3990 -1730 {lab=VDD}
N -3690 -1690 -3610 -1690 {lab=D7}
N -3500 -1690 -3400 -1690 {lab=D7b}
N -3570 -1780 -3570 -1730 {lab=VDD}
N -3300 -1690 -3220 -1690 {lab=D6}
N -3110 -1690 -3010 -1690 {lab=D6b}
N -3180 -1780 -3180 -1730 {lab=VDD}
N -2930 -1690 -2850 -1690 {lab=D5}
N -2740 -1690 -2640 -1690 {lab=D5b}
N -2810 -1780 -2810 -1730 {lab=VDD}
N -2500 -1690 -2420 -1690 {lab=D4}
N -2310 -1690 -2210 -1690 {lab=D4b}
N -2380 -1780 -2380 -1730 {lab=VDD}
N -2060 -1690 -1980 -1690 {lab=D3}
N -1870 -1690 -1770 -1690 {lab=D3b}
N -1940 -1780 -1940 -1730 {lab=VDD}
N -1610 -1690 -1530 -1690 {lab=D2}
N -1420 -1690 -1320 -1690 {lab=D2b}
N -1490 -1780 -1490 -1730 {lab=VDD}
N -1150 -1690 -1070 -1690 {lab=D1}
N -960 -1690 -860 -1690 {lab=D1b}
N -1030 -1780 -1030 -1730 {lab=VDD}
N -750 -1690 -670 -1690 {lab=D0}
N -560 -1690 -460 -1690 {lab=D0b}
N -630 -1780 -630 -1730 {lab=VDD}
N -6020 -1420 -5980 -1420 {lab=VDD}
N -5980 -1420 -640 -1420 {lab=VDD}
N -640 -1420 -640 -1350 {lab=VDD}
N -1040 -1420 -1040 -1350 {lab=VDD}
N -1500 -1420 -1500 -1350 {lab=VDD}
N -1950 -1420 -1950 -1350 {lab=VDD}
N -2390 -1420 -2390 -1350 {lab=VDD}
N -2820 -1420 -2820 -1350 {lab=VDD}
N -3170 -1420 -3170 -1350 {lab=VDD}
N -3580 -1420 -3580 -1350 {lab=VDD}
N -3990 -1420 -3990 -1350 {lab=VDD}
N -4390 -1420 -4390 -1350 {lab=VDD}
N -4770 -1420 -4770 -1350 {lab=VDD}
N -5190 -1420 -5190 -1350 {lab=VDD}
N -6030 -1220 -5980 -1220 {lab=VSS}
N -5980 -1220 -640 -1220 {lab=VSS}
N -640 -1270 -640 -1220 {lab=VSS}
N -1040 -1270 -1040 -1220 {lab=VSS}
N -1500 -1270 -1500 -1220 {lab=VSS}
N -1950 -1270 -1950 -1220 {lab=VSS}
N -2390 -1270 -2390 -1220 {lab=VSS}
N -2820 -1270 -2820 -1220 {lab=VSS}
N -3170 -1270 -3170 -1220 {lab=VSS}
N -3580 -1270 -3580 -1220 {lab=VSS}
N -3990 -1270 -3990 -1220 {lab=VSS}
N -4390 -1270 -4390 -1220 {lab=VSS}
N -4770 -1270 -4770 -1220 {lab=VSS}
N -5190 -1270 -5190 -1220 {lab=VSS}
N -5970 -1780 -630 -1780 {lab=VDD}
N -5970 -1800 -5970 -1780 {lab=VDD}
N -5970 -1610 -5970 -1590 {lab=VSS}
N -5970 -1610 -630 -1610 {lab=VSS}
N -630 -1650 -630 -1610 {lab=VSS}
N -1030 -1650 -1030 -1610 {lab=VSS}
N -1490 -1650 -1490 -1610 {lab=VSS}
N -1940 -1650 -1940 -1610 {lab=VSS}
N -2380 -1650 -2380 -1610 {lab=VSS}
N -2810 -1650 -2810 -1610 {lab=VSS}
N -3180 -1650 -3180 -1610 {lab=VSS}
N -3570 -1650 -3570 -1610 {lab=VSS}
N -3990 -1650 -3990 -1610 {lab=VSS}
N -4390 -1650 -4390 -1610 {lab=VSS}
N -4770 -1650 -4770 -1610 {lab=VSS}
N -5170 -1650 -5170 -1610 {lab=VSS}
N -6020 -970 -5980 -970 {lab=VDD}
N -5980 -970 -640 -970 {lab=VDD}
N -5980 -800 -640 -800 {lab=VSS}
N -1040 -810 -1040 -800 {lab=VSS}
N -6020 -800 -5980 -800 {lab=VSS}
N -6080 -1370 -5560 -1370 {lab=CLK1}
N -5560 -1370 -5390 -1370 {lab=CLK1}
N -5390 -1370 -720 -1370 {lab=CLK1}
N -720 -1370 -720 -1320 {lab=CLK1}
N -720 -1320 -680 -1320 {lab=CLK1}
N -1120 -1370 -1120 -1320 {lab=CLK1}
N -1120 -1320 -1080 -1320 {lab=CLK1}
N -1580 -1370 -1580 -1320 {lab=CLK1}
N -1580 -1320 -1540 -1320 {lab=CLK1}
N -2040 -1370 -2040 -1320 {lab=CLK1}
N -2040 -1320 -1990 -1320 {lab=CLK1}
N -2470 -1370 -2470 -1320 {lab=CLK1}
N -2470 -1320 -2430 -1320 {lab=CLK1}
N -2910 -1370 -2910 -1320 {lab=CLK1}
N -2910 -1320 -2860 -1320 {lab=CLK1}
N -3260 -1370 -3260 -1320 {lab=CLK1}
N -3260 -1320 -3210 -1320 {lab=CLK1}
N -3660 -1370 -3660 -1320 {lab=CLK1}
N -3660 -1320 -3620 -1320 {lab=CLK1}
N -4080 -1370 -4080 -1320 {lab=CLK1}
N -4080 -1320 -4030 -1320 {lab=CLK1}
N -4480 -1370 -4480 -1330 {lab=CLK1}
N -4480 -1330 -4480 -1320 {lab=CLK1}
N -4480 -1320 -4430 -1320 {lab=CLK1}
N -4860 -1370 -4860 -1320 {lab=CLK1}
N -4860 -1320 -4810 -1320 {lab=CLK1}
N -5280 -1370 -5280 -1320 {lab=CLK1}
N -5280 -1320 -5230 -1320 {lab=CLK1}
N -6060 -950 -6060 -940 {lab=CLK2}
N -6060 -940 -710 -940 {lab=CLK2}
N -710 -940 -710 -900 {lab=CLK2}
N -710 -900 -680 -900 {lab=CLK2}
N -1110 -940 -1110 -900 {lab=CLK2}
N -1110 -900 -1080 -900 {lab=CLK2}
N -1570 -940 -1570 -900 {lab=CLK2}
N -1570 -900 -1540 -900 {lab=CLK2}
N -2020 -940 -2020 -900 {lab=CLK2}
N -2020 -900 -1990 -900 {lab=CLK2}
N -2440 -940 -2440 -900 {lab=CLK2}
N -2440 -900 -2410 -900 {lab=CLK2}
N -2900 -940 -2900 -900 {lab=CLK2}
N -2900 -900 -2860 -900 {lab=CLK2}
N -3250 -940 -3250 -900 {lab=CLK2}
N -3250 -900 -3210 -900 {lab=CLK2}
N -3660 -940 -3660 -900 {lab=CLK2}
N -3660 -900 -3620 -900 {lab=CLK2}
N -4060 -940 -4060 -900 {lab=CLK2}
N -4060 -900 -4020 -900 {lab=CLK2}
N -4460 -940 -4460 -900 {lab=CLK2}
N -4460 -900 -4420 -900 {lab=CLK2}
N -4840 -940 -4840 -900 {lab=CLK2}
N -4840 -900 -4800 -900 {lab=CLK2}
N -5270 -940 -5270 -900 {lab=CLK2}
N -5270 -900 -5230 -900 {lab=CLK2}
N -5280 -1300 -5230 -1300 {lab=D11b}
N -4860 -1300 -4810 -1300 {lab=D10b}
N -4480 -1300 -4430 -1300 {lab=D9b}
N -4080 -1300 -4030 -1300 {lab=D8b}
N -3660 -1300 -3620 -1300 {lab=D7b}
N -3260 -1300 -3210 -1300 {lab=D6b}
N -2910 -1300 -2860 -1300 {lab=D5b}
N -2470 -1300 -2430 -1300 {lab=D4b}
N -2040 -1300 -1990 -1300 {lab=D3b}
N -1580 -1300 -1540 -1300 {lab=D2b}
N -1120 -1300 -1080 -1300 {lab=D1b}
N -720 -1300 -680 -1300 {lab=D0b}
N -5270 -880 -5230 -880 {lab=D11b}
N -4840 -880 -4800 -880 {lab=D10b}
N -4460 -880 -4420 -880 {lab=D9b}
N -4060 -880 -4020 -880 {lab=D8b}
N -3660 -880 -3620 -880 {lab=D7b}
N -3250 -880 -3210 -880 {lab=D6b}
N -2900 -880 -2860 -880 {lab=D5b}
N -2440 -880 -2410 -880 {lab=D4b}
N -2020 -880 -1990 -880 {lab=D3b}
N -1570 -880 -1540 -880 {lab=D2b}
N -1110 -880 -1080 -880 {lab=D1b}
N -710 -880 -680 -880 {lab=D0b}
N -5130 -1310 -5090 -1310 {lab=D11A}
N -4710 -1310 -4680 -1310 {lab=D10A}
N -4330 -1310 -4290 -1310 {lab=D9A}
N -3930 -1310 -3900 -1310 {lab=D8A}
N -3520 -1310 -3480 -1310 {lab=D7A}
N -3110 -1310 -3080 -1310 {lab=D6A}
N -2760 -1310 -2730 -1310 {lab=D5A}
N -2330 -1310 -2290 -1310 {lab=D4A}
N -1890 -1310 -1860 -1310 {lab=D3A}
N -1440 -1310 -1400 -1310 {lab=D2A}
N -980 -1310 -930 -1310 {lab=D1A}
N -580 -1310 -540 -1310 {lab=D0A}
N -6060 -1980 -6010 -1980 {lab=CLK}
N -5880 -2070 -5880 -2040 {lab=VDD}
N -5840 -2070 -5840 -2040 {lab=VSS}
N -5710 -1990 -5670 -1990 {lab=CLK1}
N -5710 -1970 -5670 -1970 {lab=#net1}
N -5670 -1970 -5620 -1970 {lab=#net1}
N -5580 -2040 -5580 -2010 {lab=VDD}
N -5580 -1930 -5580 -1900 {lab=VSS}
N -5510 -1970 -5380 -1970 {lab=CLK2}
N -5900 -2360 -5900 -2330 {lab=VDD}
N -5900 -2250 -5900 -2220 {lab=VSS}
N -6050 -2290 -5940 -2290 {lab=PD}
N -5830 -2290 -5690 -2290 {lab=#net2}
N -5270 -2360 -5270 -2330 {lab=VDD}
N -5270 -2270 -5270 -2240 {lab=VSS}
N -5380 -2290 -5310 -2290 {lab=#net2}
N -5690 -2290 -5380 -2290 {lab=#net2}
N -5230 -2300 -5150 -2300 {lab=resetPD}
N -1910 -1310 -1890 -1310 {lab=D3A}
N -5190 -850 -5190 -800 {lab=VSS}
N -5190 -970 -5190 -930 {lab=VDD}
N -5130 -890 -5110 -890 {lab=D11bO}
N -4760 -970 -4760 -930 {lab=VDD}
N -4760 -850 -4760 -800 {lab=VSS}
N -4700 -890 -4680 -890 {lab=D10bO}
N -4380 -970 -4380 -930 {lab=VDD}
N -4380 -850 -4380 -800 {lab=VSS}
N -4320 -890 -4300 -890 {lab=D9bO}
N -3980 -970 -3980 -930 {lab=VDD}
N -3980 -850 -3980 -800 {lab=VSS}
N -3920 -890 -3900 -890 {lab=D8bO}
N -3580 -970 -3580 -930 {lab=VDD}
N -3580 -850 -3580 -800 {lab=VSS}
N -3520 -890 -3500 -890 {lab=D7bO}
N -3170 -970 -3170 -930 {lab=VDD}
N -3170 -850 -3170 -800 {lab=VSS}
N -3110 -890 -3100 -890 {lab=D6bO}
N -2820 -970 -2820 -930 {lab=VDD}
N -2820 -850 -2820 -800 {lab=VSS}
N -2760 -890 -2750 -890 {lab=D5bO}
N -2370 -850 -2370 -800 {lab=VSS}
N -2370 -970 -2370 -930 {lab=VDD}
N -2310 -890 -2280 -890 {lab=D4bO}
N -1950 -970 -1950 -930 {lab=VDD}
N -1950 -850 -1950 -800 {lab=VSS}
N -1890 -890 -1880 -890 {lab=D3bO}
N -1500 -970 -1500 -930 {lab=VDD}
N -1500 -850 -1500 -800 {lab=VSS}
N -1440 -890 -1420 -890 {lab=D2bO}
N -1040 -970 -1040 -930 {lab=VDD}
N -1040 -850 -1040 -810 {lab=VSS}
N -980 -890 -960 -890 {lab=D1bO}
N -640 -970 -640 -930 {lab=VDD}
N -640 -850 -640 -800 {lab=VSS}
N -580 -890 -560 -890 {lab=D0bO}
N -5520 -2380 -5450 -2380 {lab=CLK2}
N -5340 -2380 -5340 -2310 {lab=#net3}
N -5340 -2310 -5310 -2310 {lab=#net3}
N -5410 -2480 -5410 -2420 {lab=VDD}
N -5410 -2480 -5260 -2480 {lab=VDD}
N -5260 -2480 -5260 -2350 {lab=VDD}
N -5270 -2350 -5260 -2350 {lab=VDD}
N -5410 -2340 -5410 -2250 {lab=VSS}
N -5410 -2250 -5270 -2250 {lab=VSS}
N 610 -50 610 -10 {lab=OUT}
N 610 -150 610 -110 {lab=OUT}
N -5230 -150 -5020 -150 {lab=OUT}
N -6360 320 -6360 360 {lab=Vrefh}
N 610 -110 610 -50 {lab=OUT}
N -180 10 -140 10 {lab=VDD}
N -180 40 -140 40 {lab=VSS}
N -180 110 -140 110 {lab=D0A}
N -180 140 -140 140 {lab=D0bO}
N -5310 -150 -5230 -150 {lab=OUT}
N -650 10 -610 10 {lab=VDD}
N -650 40 -610 40 {lab=VSS}
N -1100 10 -1060 10 {lab=VDD}
N -1100 40 -1060 40 {lab=VSS}
N -1630 10 -1590 10 {lab=VDD}
N -1630 40 -1590 40 {lab=VSS}
N -2060 10 -2020 10 {lab=VDD}
N -2060 40 -2020 40 {lab=VSS}
N -2530 10 -2490 10 {lab=VDD}
N -2530 40 -2490 40 {lab=VSS}
N -2980 10 -2940 10 {lab=VDD}
N -2980 40 -2940 40 {lab=VSS}
N -3510 10 -3470 10 {lab=VDD}
N -3510 40 -3470 40 {lab=VSS}
N -4030 10 -3990 10 {lab=VDD}
N -4030 40 -3990 40 {lab=VSS}
N -4560 10 -4520 10 {lab=VDD}
N -4560 40 -4520 40 {lab=VSS}
N -4990 10 -4950 10 {lab=VDD}
N -4990 40 -4950 40 {lab=VSS}
N -5460 10 -5420 10 {lab=VDD}
N -5460 40 -5420 40 {lab=VSS}
N -5480 110 -5420 110 {lab=D11A}
N -5480 140 -5420 140 {lab=D11bO}
N -5010 110 -4950 110 {lab=D10A}
N -5010 140 -4950 140 {lab=D10bO}
N -4580 110 -4520 110 {lab=D9A}
N -4580 140 -4520 140 {lab=D9bO}
N -4050 110 -3990 110 {lab=D8A}
N -4050 140 -3990 140 {lab=D8bO}
N -3530 110 -3470 110 {lab=D7A}
N -3530 140 -3470 140 {lab=D7bO}
N -3000 110 -2940 110 {lab=D6A}
N -3000 140 -2940 140 {lab=D6bO}
N -2550 110 -2490 110 {lab=D5A}
N -2550 140 -2490 140 {lab=D5bO}
N -2080 110 -2020 110 {lab=D4A}
N -2080 140 -2020 140 {lab=D4bO}
N -1650 110 -1590 110 {lab=D3A}
N -1650 140 -1590 140 {lab=D3bO}
N -1120 110 -1060 110 {lab=D2A}
N -1120 140 -1060 140 {lab=D2bO}
N -670 110 -610 110 {lab=D1A}
N -670 140 -610 140 {lab=D1bO}
N 610 130 610 150 {lab=Vrefl}
N 560 100 570 100 {lab=resetPD}
N 610 -10 610 70 {lab=OUT}
C {capa.sym} 370 -30 0 0 {name=C1
m=1
value=21.12f
footprint=1206
device="ceramic capacitor"}
C {opin.sym} 650 -150 0 0 {name=p1 lab=OUT}
C {iopin.sym} -6360 360 1 0 {name=p2 lab=Vrefh}
C {iopin.sym} -6210 360 1 0 {name=p3 lab=Vrefl}
C {lab_wire.sym} 640 100 2 0 {name=p22 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -5970 -1800 0 0 {name=p32 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -5970 -1590 0 0 {name=p33 sig_type=std_logic lab=VSS}
C {ipin.sym} -5290 -1690 0 0 {name=p38 lab=D11}
C {INV.sym} -5060 -1690 0 0 {name=x17}
C {lab_wire.sym} -5000 -1690 0 0 {name=p39 sig_type=std_logic lab=D11b}
C {ipin.sym} -4890 -1690 0 0 {name=p42 lab=D10}
C {INV.sym} -4660 -1690 0 0 {name=x18}
C {lab_wire.sym} -4600 -1690 0 0 {name=p43 sig_type=std_logic lab=D10b}
C {lab_wire.sym} -1650 110 0 0 {name=p46 sig_type=std_logic lab=D3A}
C {lab_wire.sym} -1650 140 0 0 {name=p47 sig_type=std_logic lab=D3bO}
C {lab_wire.sym} -1120 110 0 0 {name=p48 sig_type=std_logic lab=D2A}
C {lab_wire.sym} -1120 140 0 0 {name=p49 sig_type=std_logic lab=D2bO}
C {lab_wire.sym} -670 110 0 0 {name=p58 sig_type=std_logic lab=D1A}
C {lab_wire.sym} -670 140 0 0 {name=p59 sig_type=std_logic lab=D1bO}
C {lab_wire.sym} -3530 110 0 0 {name=p26 sig_type=std_logic lab=D7A}
C {lab_wire.sym} -3530 140 0 0 {name=p27 sig_type=std_logic lab=D7bO}
C {lab_wire.sym} -3000 110 0 0 {name=p28 sig_type=std_logic lab=D6A}
C {lab_wire.sym} -3000 140 0 0 {name=p54 sig_type=std_logic lab=D6bO}
C {lab_wire.sym} -2550 110 0 0 {name=p67 sig_type=std_logic lab=D5A}
C {lab_wire.sym} -2550 140 0 0 {name=p68 sig_type=std_logic lab=D5bO}
C {lab_wire.sym} -2080 140 0 0 {name=p69 sig_type=std_logic lab=D4bO}
C {lab_wire.sym} -2080 110 0 0 {name=p70 sig_type=std_logic lab=D4A}
C {lab_wire.sym} -4580 110 0 0 {name=p79 sig_type=std_logic lab=D9A}
C {lab_wire.sym} -4580 140 0 0 {name=p80 sig_type=std_logic lab=D9bO}
C {lab_wire.sym} -4050 110 0 0 {name=p81 sig_type=std_logic lab=D8A}
C {lab_wire.sym} -4050 140 0 0 {name=p82 sig_type=std_logic lab=D8bO}
C {lab_wire.sym} -5480 110 0 0 {name=p103 sig_type=std_logic lab=D11A}
C {lab_wire.sym} -5480 140 0 0 {name=p104 sig_type=std_logic lab=D11bO}
C {lab_wire.sym} -5010 140 0 0 {name=p105 sig_type=std_logic lab=D10bO}
C {lab_wire.sym} -5010 110 0 0 {name=p106 sig_type=std_logic lab=D10A}
C {ipin.sym} -4510 -1690 0 0 {name=p107 lab=D9}
C {INV.sym} -4280 -1690 0 0 {name=x34}
C {lab_wire.sym} -4220 -1690 0 0 {name=p108 sig_type=std_logic lab=D9b}
C {ipin.sym} -4110 -1690 0 0 {name=p111 lab=D8}
C {INV.sym} -3880 -1690 0 0 {name=x35}
C {lab_wire.sym} -3820 -1690 0 0 {name=p112 sig_type=std_logic lab=D8b}
C {ipin.sym} -3690 -1690 0 0 {name=p115 lab=D7}
C {INV.sym} -3460 -1690 0 0 {name=x36}
C {lab_wire.sym} -3400 -1690 0 0 {name=p116 sig_type=std_logic lab=D7b}
C {ipin.sym} -3300 -1690 0 0 {name=p119 lab=D6}
C {INV.sym} -3070 -1690 0 0 {name=x37}
C {lab_wire.sym} -3010 -1690 0 0 {name=p120 sig_type=std_logic lab=D6b}
C {ipin.sym} -2930 -1690 0 0 {name=p123 lab=D5}
C {INV.sym} -2700 -1690 0 0 {name=x38}
C {lab_wire.sym} -2640 -1690 0 0 {name=p124 sig_type=std_logic lab=D5b}
C {ipin.sym} -2500 -1690 0 0 {name=p127 lab=D4}
C {INV.sym} -2270 -1690 0 0 {name=x39}
C {lab_wire.sym} -2210 -1690 0 0 {name=p128 sig_type=std_logic lab=D4b}
C {ipin.sym} -2060 -1690 0 0 {name=p131 lab=D3}
C {INV.sym} -1830 -1690 0 0 {name=x40}
C {lab_wire.sym} -1770 -1690 0 0 {name=p132 sig_type=std_logic lab=D3b}
C {ipin.sym} -1610 -1690 0 0 {name=p135 lab=D2}
C {INV.sym} -1380 -1690 0 0 {name=x41}
C {lab_wire.sym} -1320 -1690 0 0 {name=p136 sig_type=std_logic lab=D2b}
C {ipin.sym} -1150 -1690 0 0 {name=p139 lab=D1}
C {INV.sym} -920 -1690 0 0 {name=x42}
C {lab_wire.sym} -860 -1690 0 0 {name=p140 sig_type=std_logic lab=D1b}
C {ipin.sym} -750 -1690 0 0 {name=p143 lab=D0}
C {INV.sym} -520 -1690 0 0 {name=x43}
C {lab_wire.sym} -460 -1690 0 0 {name=p144 sig_type=std_logic lab=D0b}
C {lab_wire.sym} -6020 -1420 0 0 {name=p36 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -6020 -970 0 0 {name=p37 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -6030 -1220 0 0 {name=p40 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -6020 -800 0 0 {name=p41 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -6060 -950 0 0 {name=p44 sig_type=std_logic lab=CLK2}
C {lab_wire.sym} -6080 -1370 0 0 {name=p45 sig_type=std_logic lab=CLK1}
C {lab_wire.sym} -5280 -1300 0 0 {name=p113 sig_type=std_logic lab=D11b}
C {lab_wire.sym} -4860 -1300 0 0 {name=p114 sig_type=std_logic lab=D10b}
C {lab_wire.sym} -4480 -1300 0 0 {name=p117 sig_type=std_logic lab=D9b}
C {lab_wire.sym} -4080 -1300 0 0 {name=p118 sig_type=std_logic lab=D8b}
C {lab_wire.sym} -3660 -1300 0 0 {name=p121 sig_type=std_logic lab=D7b}
C {lab_wire.sym} -3260 -1300 0 0 {name=p122 sig_type=std_logic lab=D6b}
C {lab_wire.sym} -2910 -1300 0 0 {name=p125 sig_type=std_logic lab=D5b}
C {lab_wire.sym} -2470 -1300 0 0 {name=p126 sig_type=std_logic lab=D4b}
C {lab_wire.sym} -2040 -1300 0 0 {name=p129 sig_type=std_logic lab=D3b}
C {lab_wire.sym} -1580 -1300 0 0 {name=p130 sig_type=std_logic lab=D2b}
C {lab_wire.sym} -1120 -1300 0 0 {name=p133 sig_type=std_logic lab=D1b}
C {lab_wire.sym} -720 -1300 0 0 {name=p134 sig_type=std_logic lab=D0b}
C {lab_wire.sym} -5270 -880 0 0 {name=p141 sig_type=std_logic lab=D11b}
C {lab_wire.sym} -4840 -880 0 0 {name=p142 sig_type=std_logic lab=D10b}
C {lab_wire.sym} -4460 -880 0 0 {name=p145 sig_type=std_logic lab=D9b}
C {lab_wire.sym} -4060 -880 0 0 {name=p146 sig_type=std_logic lab=D8b}
C {lab_wire.sym} -3660 -880 0 0 {name=p147 sig_type=std_logic lab=D7b}
C {lab_wire.sym} -3250 -880 0 0 {name=p148 sig_type=std_logic lab=D6b}
C {lab_wire.sym} -2900 -880 0 0 {name=p149 sig_type=std_logic lab=D5b}
C {lab_wire.sym} -2440 -880 0 0 {name=p150 sig_type=std_logic lab=D4b}
C {lab_wire.sym} -2020 -880 0 0 {name=p151 sig_type=std_logic lab=D3b}
C {lab_wire.sym} -1560 -880 0 0 {name=p152 sig_type=std_logic lab=D2b}
C {lab_wire.sym} -1110 -880 0 0 {name=p153 sig_type=std_logic lab=D1b}
C {lab_wire.sym} -710 -880 0 0 {name=p154 sig_type=std_logic lab=D0b}
C {lab_wire.sym} -5090 -1310 0 0 {name=p157 sig_type=std_logic lab=D11A}
C {lab_wire.sym} -4680 -1310 0 0 {name=p158 sig_type=std_logic lab=D10A}
C {lab_wire.sym} -4290 -1310 0 0 {name=p159 sig_type=std_logic lab=D9A}
C {lab_wire.sym} -3900 -1310 0 0 {name=p160 sig_type=std_logic lab=D8A}
C {lab_wire.sym} -3480 -1310 0 0 {name=p161 sig_type=std_logic lab=D7A}
C {lab_wire.sym} -3080 -1310 0 0 {name=p162 sig_type=std_logic lab=D6A}
C {lab_wire.sym} -2730 -1310 0 0 {name=p163 sig_type=std_logic lab=D5A}
C {lab_wire.sym} -2290 -1310 0 0 {name=p164 sig_type=std_logic lab=D4A}
C {lab_wire.sym} -1860 -1310 0 0 {name=p165 sig_type=std_logic lab=D3A}
C {lab_wire.sym} -1400 -1310 0 0 {name=p166 sig_type=std_logic lab=D2A}
C {lab_wire.sym} -930 -1310 0 0 {name=p167 sig_type=std_logic lab=D1A}
C {lab_wire.sym} -540 -1310 0 0 {name=p168 sig_type=std_logic lab=D0A}
C {lab_wire.sym} -5110 -890 0 0 {name=p171 sig_type=std_logic lab=D11bO}
C {lab_wire.sym} -4680 -890 0 0 {name=p172 sig_type=std_logic lab=D10bO}
C {lab_wire.sym} -4300 -890 0 0 {name=p173 sig_type=std_logic lab=D9bO}
C {lab_wire.sym} -3900 -890 0 0 {name=p174 sig_type=std_logic lab=D8bO}
C {lab_wire.sym} -3500 -890 0 0 {name=p175 sig_type=std_logic lab=D7bO}
C {lab_wire.sym} -3100 -890 0 0 {name=p176 sig_type=std_logic lab=D6bO}
C {lab_wire.sym} -2750 -890 0 0 {name=p177 sig_type=std_logic lab=D5bO}
C {lab_wire.sym} -2280 -890 0 0 {name=p178 sig_type=std_logic lab=D4bO}
C {lab_wire.sym} -1880 -890 0 0 {name=p179 sig_type=std_logic lab=D3bO}
C {lab_wire.sym} -1420 -890 0 0 {name=p180 sig_type=std_logic lab=D2bO}
C {lab_wire.sym} -960 -890 0 0 {name=p181 sig_type=std_logic lab=D1bO}
C {lab_wire.sym} -560 -890 0 0 {name=p182 sig_type=std_logic lab=D0bO}
C {ipin.sym} -6060 -1980 0 0 {name=p183 lab=CLK}
C {NOL.sym} -5860 -1980 0 0 {name=x72}
C {lab_wire.sym} -5880 -2070 0 0 {name=p184 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -5840 -2070 0 0 {name=p185 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -5670 -1990 0 0 {name=p186 sig_type=std_logic lab=CLK1}
C {lab_wire.sym} -5380 -1970 0 0 {name=p187 sig_type=std_logic lab=CLK2}
C {INV.sym} -5470 -1970 0 0 {name=x73}
C {lab_wire.sym} -5580 -2040 0 0 {name=p4 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -5580 -1900 0 0 {name=p5 sig_type=std_logic lab=VSS}
C {ipin.sym} -6050 -2290 0 0 {name=p9 lab=PD}
C {INV.sym} -5790 -2290 0 0 {name=x74}
C {lab_wire.sym} -5900 -2360 0 0 {name=p11 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -5900 -2220 0 0 {name=p14 sig_type=std_logic lab=VSS}
C {OR.sym} -5170 -2300 0 0 {name=x75}
C {lab_wire.sym} -5270 -2360 0 0 {name=p19 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -5270 -2240 0 0 {name=p20 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -5520 -2380 0 0 {name=p16 sig_type=std_logic lab=CLK2}
C {lab_wire.sym} -5150 -2300 0 0 {name=p23 sig_type=std_logic lab=resetPD}
C {lab_wire.sym} 530 100 0 0 {name=p24 sig_type=std_logic lab=resetPD}
C {IMPLY.sym} -5260 -1240 0 0 {name=x46}
C {IMPLY.sym} -4840 -1240 0 0 {name=x47}
C {IMPLY.sym} -4460 -1240 0 0 {name=x48}
C {IMPLY.sym} -4060 -1240 0 0 {name=x49}
C {IMPLY.sym} -3650 -1240 0 0 {name=x50}
C {IMPLY.sym} -3240 -1240 0 0 {name=x51}
C {IMPLY.sym} -2890 -1240 0 0 {name=x52}
C {IMPLY.sym} -2460 -1240 0 0 {name=x53}
C {IMPLY.sym} -2020 -1240 0 0 {name=x54}
C {IMPLY.sym} -1570 -1240 0 0 {name=x55}
C {IMPLY.sym} -1110 -1240 0 0 {name=x56}
C {IMPLY.sym} -710 -1240 0 0 {name=x57}
C {IMPLY.sym} -710 -820 0 0 {name=x58}
C {IMPLY.sym} -1110 -820 0 0 {name=x59}
C {IMPLY.sym} -1570 -820 0 0 {name=x60}
C {IMPLY.sym} -2020 -820 0 0 {name=x61}
C {IMPLY.sym} -2440 -820 0 0 {name=x62}
C {IMPLY.sym} -2890 -820 0 0 {name=x63}
C {IMPLY.sym} -3240 -820 0 0 {name=x64}
C {IMPLY.sym} -3650 -820 0 0 {name=x65}
C {IMPLY.sym} -4050 -820 0 0 {name=x66}
C {IMPLY.sym} -4450 -820 0 0 {name=x67}
C {IMPLY.sym} -4830 -820 0 0 {name=x68}
C {IMPLY.sym} -5260 -820 0 0 {name=x69}
C {INV.sym} -5300 -2380 0 0 {name=x76}
C {iopin.sym} -5460 10 2 0 {name=p25 lab=VDD}
C {iopin.sym} -5460 40 2 0 {name=p29 lab=VSS}
C {Cunit.sym} -70 140 0 0 {name=x2}
C {lab_wire.sym} -180 40 0 0 {name=p6 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -180 10 0 0 {name=p30 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -180 140 0 0 {name=p31 sig_type=std_logic lab=D0bO}
C {lab_wire.sym} -180 110 0 0 {name=p34 sig_type=std_logic lab=D0A}
C {2048Cu.sym} -5250 290 0 0 {name=x3}
C {1024Cu.sym} -4720 280 0 0 {name=x4}
C {512Cu.sym} -4320 230 0 0 {name=x5}
C {256Cu.sym} -3900 180 0 0 {name=x6}
C {128Cu.sym} -3380 210 0 0 {name=x7}
C {64Cu.sym} -3090 330 0 0 {name=x8}
C {32Cu.sym} -2470 230 0 0 {name=x9}
C {16Cu.sym} -1930 210 0 0 {name=x10}
C {8Cu.sym} -1610 130 0 0 {name=x11}
C {4Cu.sym} -890 140 0 0 {name=x12}
C {2Cu.sym} -450 130 0 0 {name=x13}
C {lab_wire.sym} -650 40 0 0 {name=p35 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -650 10 0 0 {name=p50 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -1100 40 0 0 {name=p53 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -1100 10 0 0 {name=p55 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -1630 40 0 0 {name=p56 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -1630 10 0 0 {name=p57 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -2060 40 0 0 {name=p60 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -2060 10 0 0 {name=p61 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -2530 40 0 0 {name=p64 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -2530 10 0 0 {name=p65 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -2980 40 0 0 {name=p71 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -2980 10 0 0 {name=p73 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -3510 40 0 0 {name=p76 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -3510 10 0 0 {name=p78 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -4030 40 0 0 {name=p83 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -4030 10 0 0 {name=p85 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -4560 40 0 0 {name=p86 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -4560 10 0 0 {name=p87 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -4990 40 0 0 {name=p88 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -4990 10 0 0 {name=p89 sig_type=std_logic lab=VDD}
C {NMOS_MIN.sym} 570 100 0 0 {name=M1 model=nch w=5u l=0.35u as=0 ps=0 ad=0 pd=0 m=20}
