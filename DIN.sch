v {xschem version=3.4.8RC file_version=1.2}
G {}
K {}
V {}
S {}
E {}
L 4 80 -450 80 -330 {}
L 4 80 -450 140 -340 {}
L 4 140 -450 140 -340 {}
L 4 210 -440 280 -440 {}
L 4 210 -440 280 -440 {}
L 4 210 -440 210 -350 {}
L 4 210 -350 280 -350 {}
L 4 210 -400 270 -400 {}
L 4 330 -440 360 -350 {}
L 4 360 -350 400 -430 {}
L 4 400 -430 430 -350 {}
L 4 430 -350 470 -430 {}
C {vsource.sym} 530 0 0 0 {name=V13 value="pulse(0 3.3 100n 1n 1n 300n 500n)" savecurrent=false}
C {vsource.sym} 590 0 0 0 {name=V12 value="pulse(0 3.3 100n 1n 1n 400n 500n)" savecurrent=false}
C {vsource.sym} 650 0 0 0 {name=V11 value="pulse(0 3.3 100n 1n 1n 300n 500n)" savecurrent=false}
C {vsource.sym} 710 0 0 0 {name=V10 value="pulse(0 3.3 100n 1n 1n 300n 500n)" savecurrent=false}
C {vsource.sym} 770 0 0 0 {name=V9 value="pulse(0 3.3 100n 1n 1n 300n 500n)" savecurrent=false}
C {vsource.sym} 830 0 0 0 {name=V8 value="pulse(0 3.3 100n 1n 1n 400n 500n)" savecurrent=false}
C {vsource.sym} 50 0 0 0 {name=V7 value="pulse(0 3.3 100n 1n 1n 100n 400n)" savecurrent=false}
C {vsource.sym} 110 0 0 0 {name=V6 value="pulse(0 3.3 100n 1n 1n 200n 300n)" savecurrent=false}
C {vsource.sym} 170 0 0 0 {name=V5 value="pulse(0 3.3 100n 1n 1n 300n 500n)" savecurrent=false}
C {vsource.sym} 230 0 0 0 {name=V4 value="pulse(0 3.3 100n 1n 1n 300n 500n)" savecurrent=false}
C {vsource.sym} 290 0 0 0 {name=V3 value="pulse(0 3.3 100n 1n 1n 300n 500n)" savecurrent=false}
C {vsource.sym} 350 0 0 0 {name=V2 value="pulse(0 3.3 100n 1n 1n 400n 500n)" savecurrent=false}
C {vsource.sym} 410 0 0 0 {name=V1 value="pulse(0 3.3  100n 1n 1n 300n 500n)" savecurrent=false}
C {vsource.sym} 470 0 0 0 {name=V0 value="pulse(0 3.3  100n 1n 1n 300n 500n)" savecurrent=false}
C {vsource.sym} 420 -270 0 0 {name=V14 value="pulse(0 3.3 100n 1n 1n 300n 500n)" savecurrent=false}
C {vsource.sym} 480 -270 0 0 {name=V15 value="pulse(0 3.3 100n 1n 1n 400n 500n)" savecurrent=false}
C {vsource.sym} 540 -270 0 0 {name=V16 value="pulse(0 3.3 100n 1n 1n 300n 500n)" savecurrent=false}
C {vsource.sym} 600 -270 0 0 {name=V17 value="pulse(0 3.3 100n 1n 1n 300n 500n)" savecurrent=false}
C {vsource.sym} 660 -270 0 0 {name=V18 value="pulse(0 3.3 100n 1n 1n 300n 500n)" savecurrent=false}
C {vsource.sym} 720 -270 0 0 {name=V19 value="pulse(0 3.3 100n 1n 1n 400n 500n)" savecurrent=false}
C {vsource.sym} 60 -270 0 0 {name=V20 value="pulse(0 3.3 200n 1n 1n 100n 500n)" savecurrent=false}
C {vsource.sym} 120 -270 0 0 {name=V21 value="pulse(0 3.3 200n 1n 1n 100n 500n)" savecurrent=false}
C {vsource.sym} 180 -270 0 0 {name=V22 value="pulse(0 3.3 200n 1n 1n 100n 500n)" savecurrent=false}
C {vsource.sym} 240 -270 0 0 {name=V23 value="pulse(0 3.3 100n 1n 1n 200n 300n)" savecurrent=false}
C {vsource.sym} 300 -270 0 0 {name=V24 value="pulse(0 3.3  100n 1n 1n 300n 500n)" savecurrent=false}
C {vsource.sym} 360 -270 0 0 {name=V25 value="pulse(0 3.3  100n 1n 1n 300n 500n)" savecurrent=false}
