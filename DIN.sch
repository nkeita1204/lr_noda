v {xschem version=3.4.8RC file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {vsource.sym} 530 0 0 0 {name=V13 value="pulse(0 3.3 100n 1n 1n 300n 500n)" savecurrent=false}
C {vsource.sym} 590 0 0 0 {name=V12 value="pulse(0 3.3 100n 1n 1n 400n 500n)" savecurrent=false}
C {vsource.sym} 650 0 0 0 {name=V11 value="pulse(0 3.3 100n 1n 1n 300n 500n)" savecurrent=false}
C {vsource.sym} 710 0 0 0 {name=V10 value="pulse(0 3.3 100n 1n 1n 300n 500n)" savecurrent=false}
C {vsource.sym} 770 0 0 0 {name=V9 value="pulse(0 3.3 100n 1n 1n 300n 500n)" savecurrent=false}
C {vsource.sym} 830 0 0 0 {name=V8 value="pulse(0 3.3 100n 1n 1n 400n 500n)" savecurrent=false}
C {vsource.sym} 50 0 0 0 {name=V7 value="pulse(0 3.3 100n 1n 1n 100n 400n)" savecurrent=false}
C {vsource.sym} 110 0 0 0 {name=V6 value="pulse(0 3.3 100n 1n 1n 200n 300n)" savecurrent=false}
C {vsource.sym} 170 0 0 0 {name=V5 value="pulse(0 3.3 100n 1n 1n 300n 500n)" savecurrent=false}
C {vsource.sym} 230 0 0 0 {name=V4 value="pulse(0 3.3 100n 1n 1n 300n 500n)" savecurrent=false}
C {vsource.sym} 290 0 0 0 {name=V3 value="pulse(0 3.3 100n 1n 1n 300n 500n)" savecurrent=false}
C {vsource.sym} 350 0 0 0 {name=V2 value="pulse(0 3.3 100n 1n 1n 400n 500n)" savecurrent=false}
C {vsource.sym} 410 0 0 0 {name=V1 value="pulse(0 3.3  100n 1n 1n 300n 500n)" savecurrent=false}
C {vsource.sym} 470 0 0 0 {name=V0 value="pulse(0 3.3  100n 1n 1n 300n 500n)" savecurrent=false}
