v {xschem version=3.0.0 file_version=1.1}
G {}
V {}
S {}
E {}
C {iopin.sym} 40 280 0 1 {name=p0 lab=In+
}
C {iopin.sym} 200 280 0 1 {name=p1 lab=In-
}
C {iopin.sym} 840 260 0 1 {name=p2 lab=out
}
C {iopin.sym} 830 -20 0 1 {name=p3 lab=VDD
}
C {iopin.sym} 830 550 0 1 {name=p4 lab=VSS
}
C {iopin.sym} -130 190 0 1 {name=p5 lab=bias
}
C {PMOS_MIN.sym} 50 40 0 1 {name=M5 l=5u w=15u}
C {PMOS_MIN.sym} 50 160 0 1 {name=M6 l=2u w=20u}
C {PMOS_MIN.sym} 80 40 0 0 {name=M7 l=5u w=15u m=2}
C {PMOS_MIN.sym} 80 160 0 0 {name=M8 l=2u w=20u m=2}
C {NMOS_MIN.sym} -60 380 0 1 {name=M1 l=2u w=10u}
C {NMOS_MIN.sym} -60 480 0 1 {name=M2 l=5u w=5u}
C {NMOS_MIN.sym} -30 380 0 0 {name=M3 l=2u w=10u}
C {NMOS_MIN.sym} -30 480 0 0 {name=M4 l=5u w=5u}
C {PMOS_MIN.sym} 420 40 0 1 {name=M11 l=5u w=20u m=5}
C {PMOS_MIN.sym} 420 170 0 1 {name=M12 l=2u w=20u m=5}
C {PMOS_MIN.sym} 450 40 0 0 {name=M13 l=5u w=20u m=5}
C {PMOS_MIN.sym} 450 170 0 0 {name=M14 l=2u w=20u m=5}
C {NMOS_MIN.sym} 420 380 0 1 {name=M15 l=2u w=20u m=5}
C {NMOS_MIN.sym} 420 480 0 1 {name=M16 l=5u w=10u}
C {NMOS_MIN.sym} 450 380 0 0 {name=M17 l=2u w=20u m=5}
C {NMOS_MIN.sym} 450 480 0 0 {name=M18 l=5u w=10u}
C {PMOS_MIN.sym} 530 270 0 1 {name=M19 l=1u w=30u m=10}
C {NMOS_MIN.sym} 540 480 0 0 {name=M20 l=5u w=1.5u m=4}
C {PMOS_MIN.sym} 620 40 0 1 {name=M21 l=1u w=30u m=10}
C {PMOS_MIN.sym} 620 140 0 1 {name=M22 l=1u w=30u m=10}
C {NMOS_MIN.sym} 690 270 0 1 {name=M23 l=1u w=20u m=5}
C {PMOS_MIN.sym} 670 100 0 0 {name=M24 l=5u w=4u m=4}
C {NMOS_MIN.sym} 750 400 0 1 {name=M25 l=1u w=20u m=5}
C {NMOS_MIN.sym} 750 480 0 1 {name=M26 l=1u w=20u m=5}
C {PMOS_MIN.sym} 770 200 0 0 {name=M27 l=1u w=30u m=10}
C {NMOS_MIN.sym} 770 330 0 0 {name=M28 l=1u w=96u m=1}
C {HR_POLY_MIN.sym} -100 80 0 0 {name=R1 value=800k}
C {CAP_MIN.sym} 740 200 0 0 {name=C1 value=1p}
C {CAP_MIN.sym} 740 330 2 0 {name=C2 value=1p}
C {PMOS_MIN.sym} 50 280 0 0 {name=M9 l=3u w=20u m=10}
C {PMOS_MIN.sym} 190 280 0 1 {name=M10 l=3u w=20u m=10}
C {NMOS_MIN.sym} 180 220 0 0 {name=M29 l=3u w=20u m=5}
C {NMOS_MIN.sym} 330 220 0 1 {name=M30 l=3u w=20u m=5}
C {NMOS_MIN.sym} 220 380 0 0 {name=M31 l=2u w=20u}
C {NMOS_MIN.sym} 220 480 0 0 {name=M32 l=5u w=10u}
N 10 -20 -100 -20 {}
N 120 -20 10 -20 {}
N 380 -20 120 -20 {}
N 490 -20 380 -20 {}
N 580 -20 490 -20 {}
N 710 -20 580 -20 {}
N 810 -20 710 -20 {}
N 830 -20 810 -20 {}
N 10 10 10 -20 {}
N 10 10 0 10 {}
N 120 10 120 -20 {}
N 130 10 120 10 {}
N 380 10 380 -20 {}
N 380 10 370 10 {}
N 490 10 490 -20 {}
N 500 10 490 10 {}
N 580 10 580 -20 {}
N 580 10 570 10 {}
N 0 40 0 10 {}
N 10 40 0 40 {}
N 60 40 50 40 {}
N 80 40 60 40 {}
N 130 40 130 10 {}
N 130 40 120 40 {}
N 370 40 370 10 {}
N 380 40 370 40 {}
N 430 40 420 40 {}
N 450 40 430 40 {}
N 500 40 500 10 {}
N 500 40 490 40 {}
N 570 40 570 10 {}
N 580 40 570 40 {}
N 710 70 710 -20 {}
N 720 70 710 70 {}
N -100 80 -100 -20 {}
N 580 80 580 70 {}
N 620 80 620 40 {}
N 620 80 580 80 {}
N 60 100 60 40 {}
N 670 100 60 100 {}
N 720 100 720 70 {}
N 720 100 710 100 {}
N 580 110 580 80 {}
N 490 120 490 70 {}
N 490 120 220 120 {}
N 10 130 10 70 {}
N 120 130 120 70 {}
N 380 140 380 70 {}
N 380 140 290 140 {}
N 490 140 490 120 {}
N 570 140 570 40 {}
N 580 140 570 140 {}
N 0 160 0 40 {}
N 10 160 0 160 {}
N 60 160 60 100 {}
N 60 160 50 160 {}
N 80 160 60 160 {}
N 130 160 130 40 {}
N 130 160 120 160 {}
N 370 170 370 40 {}
N 380 170 370 170 {}
N 430 170 430 40 {}
N 430 170 420 170 {}
N 450 170 430 170 {}
N 500 170 500 40 {}
N 500 170 490 170 {}
N 810 170 810 -20 {}
N 820 170 810 170 {}
N 580 180 580 170 {}
N 620 180 620 140 {}
N 620 180 580 180 {}
N -100 190 -100 140 {}
N -100 190 -130 190 {}
N 220 190 220 120 {}
N 290 190 290 140 {}
N 650 200 490 200 {}
N 740 200 650 200 {}
N 770 200 740 200 {}
N 820 200 820 170 {}
N 820 200 810 200 {}
N 10 210 10 190 {}
N 60 210 60 160 {}
N 60 210 10 210 {}
N 380 210 380 200 {}
N 430 210 430 170 {}
N 430 210 380 210 {}
N 180 220 50 220 {}
N 270 220 220 220 {}
N 290 220 270 220 {}
N 100 240 90 240 {}
N 120 240 120 190 {}
N 120 240 100 240 {}
N 140 240 120 240 {}
N 150 240 140 240 {}
N 490 240 490 200 {}
N 650 240 650 200 {}
N 90 250 90 240 {}
N 150 250 150 240 {}
N 260 250 220 250 {}
N 290 250 260 250 {}
N 330 260 330 220 {}
N 330 260 190 260 {}
N 810 260 810 230 {}
N 810 260 740 260 {}
N 840 260 810 260 {}
N 370 270 370 170 {}
N 490 270 370 270 {}
N 580 270 580 180 {}
N 580 270 530 270 {}
N 650 270 640 270 {}
N 710 270 710 130 {}
N 710 270 690 270 {}
N 740 270 740 260 {}
N 50 280 50 220 {}
N 50 280 40 280 {}
N 100 280 100 240 {}
N 100 280 90 280 {}
N 140 280 140 240 {}
N 150 280 140 280 {}
N 190 280 190 260 {}
N 200 280 190 280 {}
N 810 300 810 260 {}
N -100 330 -100 190 {}
N -50 330 -100 330 {}
N 490 330 490 300 {}
N 650 330 650 300 {}
N 650 330 490 330 {}
N 740 330 650 330 {}
N 770 330 740 330 {}
N 820 330 810 330 {}
N -100 350 -100 330 {}
N 10 350 10 210 {}
N 260 350 260 250 {}
N 380 350 380 210 {}
N 490 350 490 330 {}
N 710 360 710 270 {}
N 750 360 710 360 {}
N 820 360 820 330 {}
N 820 360 810 360 {}
N 710 370 710 360 {}
N -100 380 -110 380 {}
N -50 380 -50 330 {}
N -50 380 -60 380 {}
N -30 380 -50 380 {}
N 20 380 10 380 {}
N 270 380 270 220 {}
N 270 380 260 380 {}
N 380 380 370 380 {}
N 430 380 420 380 {}
N 450 380 430 380 {}
N 500 380 490 380 {}
N 710 400 700 400 {}
N 750 400 750 360 {}
N 150 420 150 310 {}
N 380 420 380 410 {}
N 380 420 150 420 {}
N 90 430 90 310 {}
N 490 430 490 410 {}
N 490 430 90 430 {}
N -50 440 -50 380 {}
N 220 440 220 380 {}
N 220 440 -50 440 {}
N 430 440 430 380 {}
N 430 440 220 440 {}
N 540 440 430 440 {}
N 710 440 710 430 {}
N 750 440 710 440 {}
N -100 450 -100 410 {}
N 10 450 10 410 {}
N 260 450 260 410 {}
N 380 450 380 420 {}
N 490 450 490 430 {}
N 580 450 580 270 {}
N 710 450 710 440 {}
N -110 480 -110 380 {}
N -100 480 -110 480 {}
N -50 480 -50 440 {}
N -50 480 -60 480 {}
N -30 480 -50 480 {}
N 20 480 20 380 {}
N 20 480 10 480 {}
N 220 480 220 440 {}
N 270 480 270 380 {}
N 270 480 260 480 {}
N 370 480 370 380 {}
N 380 480 370 480 {}
N 430 480 430 440 {}
N 430 480 420 480 {}
N 450 480 430 480 {}
N 500 480 500 380 {}
N 500 480 490 480 {}
N 540 480 540 440 {}
N 590 480 580 480 {}
N 700 480 700 400 {}
N 710 480 700 480 {}
N 750 480 750 440 {}
N -110 510 -110 480 {}
N -100 510 -110 510 {}
N 20 510 20 480 {}
N 20 510 10 510 {}
N 270 510 270 480 {}
N 270 510 260 510 {}
N 370 510 370 480 {}
N 380 510 370 510 {}
N 500 510 500 480 {}
N 500 510 490 510 {}
N 590 510 590 480 {}
N 590 510 580 510 {}
N 700 510 700 480 {}
N 710 510 700 510 {}
N -100 550 -100 510 {}
N 10 550 10 510 {}
N 10 550 -100 550 {}
N 260 550 260 510 {}
N 260 550 10 550 {}
N 380 550 380 510 {}
N 380 550 260 550 {}
N 490 550 490 510 {}
N 490 550 380 550 {}
N 580 550 580 510 {}
N 580 550 490 550 {}
N 640 550 640 270 {}
N 640 550 580 550 {}
N 710 550 710 510 {}
N 710 550 640 550 {}
N 810 550 810 360 {}
N 810 550 710 550 {}
N 830 550 810 550 {}
