v {xschem version=3.4.8RC file_version=1.2}
G {}
K {}
V {}
S {}
E {}
N 10 -20 120 -20 {lab=VDD}
N 120 -20 380 -20 {lab=VDD}
N 380 -20 490 -20 {lab=VDD}
N 490 -20 580 -20 {lab=VDD}
N 580 -20 710 -20 {lab=VDD}
N 710 -20 810 -20 {lab=VDD}
N 810 -20 830 -20 {lab=VDD}
N 10 -20 10 10 {lab=VDD}
N 0 10 10 10 {lab=VDD}
N 120 -20 120 10 {lab=VDD}
N 120 10 130 10 {lab=VDD}
N 380 -20 380 10 {lab=VDD}
N 370 10 380 10 {lab=VDD}
N 490 -20 490 10 {lab=VDD}
N 490 10 500 10 {lab=VDD}
N 580 -20 580 10 {lab=VDD}
N 570 10 580 10 {lab=VDD}
N 0 10 0 40 {lab=VDD}
N 0 40 10 40 {lab=VDD}
N 50 40 60 40 {lab=#net1}
N 60 40 80 40 {lab=#net1}
N 130 10 130 40 {lab=VDD}
N 120 40 130 40 {lab=VDD}
N 370 10 370 40 {lab=VDD}
N 370 40 380 40 {lab=VDD}
N 420 40 430 40 {lab=#net2}
N 430 40 450 40 {lab=#net2}
N 500 10 500 40 {lab=VDD}
N 490 40 500 40 {lab=VDD}
N 570 10 570 40 {lab=VDD}
N 570 40 580 40 {lab=VDD}
N 710 -20 710 70 {lab=VDD}
N 710 70 720 70 {lab=VDD}
N 580 70 580 80 {lab=#net3}
N 620 40 620 80 {lab=#net3}
N 580 80 620 80 {lab=#net3}
N 60 40 60 100 {lab=#net1}
N 60 100 670 100 {lab=#net1}
N 720 70 720 100 {lab=VDD}
N 710 100 720 100 {lab=VDD}
N 580 80 580 110 {lab=#net3}
N 490 70 490 120 {lab=#net4}
N 220 120 490 120 {lab=#net4}
N 10 70 10 130 {lab=#net5}
N 120 70 120 130 {lab=#net6}
N 380 70 380 140 {lab=#net7}
N 290 140 380 140 {lab=#net7}
N 490 120 490 140 {lab=#net4}
N 570 40 570 140 {lab=VDD}
N 570 140 580 140 {lab=VDD}
N 0 40 0 160 {lab=VDD}
N 0 160 10 160 {lab=VDD}
N 60 100 60 160 {lab=#net1}
N 50 160 60 160 {lab=#net1}
N 60 160 80 160 {lab=#net1}
N 130 40 130 160 {lab=VDD}
N 120 160 130 160 {lab=VDD}
N 370 40 370 170 {lab=VDD}
N 370 170 380 170 {lab=VDD}
N 430 40 430 170 {lab=#net2}
N 420 170 430 170 {lab=#net2}
N 430 170 450 170 {lab=#net2}
N 500 40 500 170 {lab=VDD}
N 490 170 500 170 {lab=VDD}
N 810 -20 810 170 {lab=VDD}
N 810 170 820 170 {lab=VDD}
N 580 170 580 180 {lab=#net8}
N 620 140 620 180 {lab=#net8}
N 580 180 620 180 {lab=#net8}
N -130 190 -100 190 {lab=bias}
N 220 120 220 190 {lab=#net4}
N 290 140 290 190 {lab=#net7}
N 490 200 650 200 {lab=#net9}
N 650 200 740 200 {lab=#net9}
N 740 200 770 200 {lab=#net9}
N 820 170 820 200 {lab=VDD}
N 810 200 820 200 {lab=VDD}
N 10 190 10 210 {lab=#net1}
N 60 160 60 210 {lab=#net1}
N 10 210 60 210 {lab=#net1}
N 380 200 380 210 {lab=#net2}
N 430 170 430 210 {lab=#net2}
N 380 210 430 210 {lab=#net2}
N 50 220 180 220 {lab=In+}
N 220 220 270 220 {lab=VSS}
N 270 220 290 220 {lab=VSS}
N 90 240 100 240 {lab=#net10}
N 120 190 120 240 {lab=#net10}
N 100 240 120 240 {lab=#net10}
N 120 240 140 240 {lab=#net10}
N 140 240 150 240 {lab=#net10}
N 490 200 490 240 {lab=#net9}
N 650 200 650 240 {lab=#net9}
N 90 240 90 250 {lab=#net10}
N 150 240 150 250 {lab=#net10}
N 220 250 260 250 {lab=#net11}
N 260 250 290 250 {lab=#net11}
N 330 220 330 260 {lab=In-}
N 190 260 330 260 {lab=In-}
N 810 230 810 260 {lab=out}
N 740 260 810 260 {lab=out}
N 810 260 840 260 {lab=out}
N 370 170 370 270 {lab=VDD}
N 370 270 490 270 {lab=VDD}
N 580 180 580 270 {lab=#net8}
N 530 270 580 270 {lab=#net8}
N 640 270 650 270 {lab=VSS}
N 710 130 710 270 {lab=#net12}
N 690 270 710 270 {lab=#net12}
N 740 260 740 270 {lab=out}
N 50 220 50 280 {lab=In+}
N 40 280 50 280 {lab=In+}
N 100 240 100 280 {lab=#net10}
N 90 280 100 280 {lab=#net10}
N 140 240 140 280 {lab=#net10}
N 140 280 150 280 {lab=#net10}
N 190 260 190 280 {lab=In-}
N 190 280 200 280 {lab=In-}
N 810 260 810 300 {lab=out}
N -100 190 -100 330 {lab=bias}
N -100 330 -50 330 {lab=bias}
N 490 300 490 330 {lab=#net13}
N 650 300 650 330 {lab=#net13}
N 490 330 650 330 {lab=#net13}
N 650 330 740 330 {lab=#net13}
N 740 330 770 330 {lab=#net13}
N 810 330 820 330 {lab=VSS}
N -100 330 -100 350 {lab=bias}
N 10 210 10 350 {lab=#net1}
N 260 250 260 350 {lab=#net11}
N 380 210 380 350 {lab=#net2}
N 490 330 490 350 {lab=#net13}
N 710 270 710 360 {lab=#net12}
N 710 360 750 360 {lab=#net12}
N 820 330 820 360 {lab=VSS}
N 810 360 820 360 {lab=VSS}
N 710 360 710 370 {lab=#net12}
N -110 380 -100 380 {lab=VSS}
N -50 330 -50 380 {lab=bias}
N -60 380 -50 380 {lab=bias}
N -50 380 -30 380 {lab=bias}
N 10 380 20 380 {lab=VSS}
N 270 220 270 380 {lab=VSS}
N 260 380 270 380 {lab=VSS}
N 370 380 380 380 {lab=VSS}
N 420 380 430 380 {lab=bias}
N 430 380 450 380 {lab=bias}
N 490 380 500 380 {lab=VSS}
N 700 400 710 400 {lab=VSS}
N 750 360 750 400 {lab=#net12}
N 150 310 150 420 {lab=#net14}
N 380 410 380 420 {lab=#net14}
N 150 420 380 420 {lab=#net14}
N 90 310 90 430 {lab=#net15}
N 490 410 490 430 {lab=#net15}
N 90 430 490 430 {lab=#net15}
N -50 380 -50 440 {lab=bias}
N 220 380 220 440 {lab=bias}
N -50 440 220 440 {lab=bias}
N 430 380 430 440 {lab=bias}
N 220 440 430 440 {lab=bias}
N 430 440 540 440 {lab=bias}
N 710 430 710 440 {lab=#net16}
N 710 440 750 440 {lab=#net16}
N -100 410 -100 450 {lab=#net17}
N 10 410 10 450 {lab=#net18}
N 260 410 260 450 {lab=#net19}
N 380 420 380 450 {lab=#net14}
N 490 430 490 450 {lab=#net15}
N 580 270 580 450 {lab=#net8}
N 710 440 710 450 {lab=#net16}
N -110 380 -110 480 {lab=VSS}
N -110 480 -100 480 {lab=VSS}
N -50 440 -50 480 {lab=bias}
N -60 480 -50 480 {lab=bias}
N -50 480 -30 480 {lab=bias}
N 20 380 20 480 {lab=VSS}
N 10 480 20 480 {lab=VSS}
N 220 440 220 480 {lab=bias}
N 270 380 270 480 {lab=VSS}
N 260 480 270 480 {lab=VSS}
N 370 380 370 480 {lab=VSS}
N 370 480 380 480 {lab=VSS}
N 430 440 430 480 {lab=bias}
N 420 480 430 480 {lab=bias}
N 430 480 450 480 {lab=bias}
N 500 380 500 480 {lab=VSS}
N 490 480 500 480 {lab=VSS}
N 540 440 540 480 {lab=bias}
N 580 480 590 480 {lab=VSS}
N 700 400 700 480 {lab=VSS}
N 700 480 710 480 {lab=VSS}
N 750 440 750 480 {lab=#net16}
N -110 480 -110 510 {lab=VSS}
N -110 510 -100 510 {lab=VSS}
N 20 480 20 510 {lab=VSS}
N 10 510 20 510 {lab=VSS}
N 270 480 270 510 {lab=VSS}
N 260 510 270 510 {lab=VSS}
N 370 480 370 510 {lab=VSS}
N 370 510 380 510 {lab=VSS}
N 500 480 500 510 {lab=VSS}
N 490 510 500 510 {lab=VSS}
N 590 480 590 510 {lab=VSS}
N 580 510 590 510 {lab=VSS}
N 700 480 700 510 {lab=VSS}
N 700 510 710 510 {lab=VSS}
N -100 510 -100 550 {lab=VSS}
N 10 510 10 550 {lab=VSS}
N -100 550 10 550 {lab=VSS}
N 260 510 260 550 {lab=VSS}
N 10 550 260 550 {lab=VSS}
N 380 510 380 550 {lab=VSS}
N 260 550 380 550 {lab=VSS}
N 490 510 490 550 {lab=VSS}
N 380 550 490 550 {lab=VSS}
N 580 510 580 550 {lab=VSS}
N 490 550 580 550 {lab=VSS}
N 640 270 640 550 {lab=VSS}
N 580 550 640 550 {lab=VSS}
N 710 510 710 550 {lab=VSS}
N 640 550 710 550 {lab=VSS}
N 810 360 810 550 {lab=VSS}
N 710 550 810 550 {lab=VSS}
N 810 550 830 550 {lab=VSS}
C {iopin.sym} 40 280 0 1 {name=p0 lab=In+
}
C {iopin.sym} 200 280 0 1 {name=p1 lab=In-
}
C {iopin.sym} 840 260 0 1 {name=p2 lab=out
}
C {iopin.sym} 830 -20 0 1 {name=p3 lab=VDD
}
C {iopin.sym} 830 550 0 1 {name=p4 lab=VSS
}
C {iopin.sym} -130 190 0 1 {name=p5 lab=bias
}
C {PMOS_MIN.sym} 50 40 0 1 {name=M5 l=5u w=15u}
C {PMOS_MIN.sym} 50 160 0 1 {name=M6 l=2u w=20u}
C {PMOS_MIN.sym} 80 40 0 0 {name=M7 l=5u w=15u m=2}
C {PMOS_MIN.sym} 80 160 0 0 {name=M8 l=2u w=20u m=2}
C {NMOS_MIN.sym} -60 380 0 1 {name=M1 l=2u w=10u}
C {NMOS_MIN.sym} -60 480 0 1 {name=M2 l=5u w=5u}
C {NMOS_MIN.sym} -30 380 0 0 {name=M3 l=2u w=10u}
C {NMOS_MIN.sym} -30 480 0 0 {name=M4 l=5u w=5u}
C {PMOS_MIN.sym} 420 40 0 1 {name=M11 l=5u w=20u m=5}
C {PMOS_MIN.sym} 420 170 0 1 {name=M12 l=2u w=20u m=5}
C {PMOS_MIN.sym} 450 40 0 0 {name=M13 l=5u w=20u m=5}
C {PMOS_MIN.sym} 450 170 0 0 {name=M14 l=2u w=20u m=5}
C {NMOS_MIN.sym} 420 380 0 1 {name=M15 l=2u w=20u m=5}
C {NMOS_MIN.sym} 420 480 0 1 {name=M16 l=5u w=10u}
C {NMOS_MIN.sym} 450 380 0 0 {name=M17 l=2u w=20u m=5}
C {NMOS_MIN.sym} 450 480 0 0 {name=M18 l=5u w=10u}
C {PMOS_MIN.sym} 530 270 0 1 {name=M19 l=1u w=30u m=10}
C {NMOS_MIN.sym} 540 480 0 0 {name=M20 l=5u w=1.5u m=4}
C {PMOS_MIN.sym} 620 40 0 1 {name=M21 l=1u w=30u m=10}
C {PMOS_MIN.sym} 620 140 0 1 {name=M22 l=1u w=30u m=10}
C {NMOS_MIN.sym} 690 270 0 1 {name=M23 l=1u w=20u m=5}
C {PMOS_MIN.sym} 670 100 0 0 {name=M24 l=5u w=4u m=4}
C {NMOS_MIN.sym} 750 400 0 1 {name=M25 l=1u w=20u m=5}
C {NMOS_MIN.sym} 750 480 0 1 {name=M26 l=1u w=20u m=5}
C {PMOS_MIN.sym} 770 200 0 0 {name=M27 l=1u w=30u m=10}
C {NMOS_MIN.sym} 770 330 0 0 {name=M28 l=1u w=96u m=1}
C {CAP_MIN.sym} 740 200 0 0 {name=C1 value=\{ccap\}}
C {CAP_MIN.sym} 740 330 2 0 {name=C2 value=\{ccap\}}
C {PMOS_MIN.sym} 50 280 0 0 {name=M9 l=3u w=20u m=10}
C {PMOS_MIN.sym} 190 280 0 1 {name=M10 l=3u w=20u m=10}
C {NMOS_MIN.sym} 180 220 0 0 {name=M29 l=3u w=20u m=5}
C {NMOS_MIN.sym} 330 220 0 1 {name=M30 l=3u w=20u m=5}
C {NMOS_MIN.sym} 220 380 0 0 {name=M31 l=2u w=20u}
C {NMOS_MIN.sym} 220 480 0 0 {name=M32 l=5u w=10u}
